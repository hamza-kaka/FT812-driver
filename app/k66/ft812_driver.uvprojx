# Keil uVision project ft812_driver.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FN2M0xxx18 NXP
  pack: NXP.MK66F18_DFP.13.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ft812_driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MK66FN2M0VLQ18
  c include: ..\..\app;.\board;..\..\CMSIS\Include;..\..\components\serial_manager;..\..\components\lists;..\..\components\uart;..\..\devices\MK66F18;..\..\devices\MK66F18\arm;..\..\devices\MK66F18\drivers;..\..\devices\MK66F18\utilities;..\..\devices\MK66F18\utilities\str;..\..\devices\MK66F18\utilities\debug_console;..\..\timers;..\..\screens;..\..\FT812 APIs;..\..\FT812 APIs\coprocessor commands;..\..\FT812 APIs\hal;..\..\FT812 APIs\image loading
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\devices\MK66F18\arm\MK66FN2M0xxx18_flash.scf
  group app
    ../: lcd_driver_main.c
  group board
    ./board/: clock_config.c clock_config.h pin_mux.c pin_mux.h
  group startup
    ../../devices/MK66F18/arm/: startup_MK66F18.s
  group FT812
    ../../FT812 APIs/: datatypes_ft81x.h ft81xdef.h
  group Drivers
    ../../devices/MK66F18/drivers/: fsl_adc16.c fsl_adc16.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rnga.c fsl_rnga.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group Devices
    ../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.c system_MK66F18.h
  group Utilities
    ../../devices/MK66F18/utilities/: fsl_assert.c
    ../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
    ../../devices/MK66F18/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group Components
    ../../components/uart/: uart.h uart_adapter.c
    ../../components/lists/: generic_list.c generic_list.h
    ../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group CMSIS
    ../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm4.h mpu_armv7.h mpu_armv8.h
  group timers
    ../../timers/: timers.c timers.h
  group FT812 Hal
    ../../FT812 APIs/hal/: gpu_hal.c gpu_hal.h Dma.c Dma.h spi.h spi.c
  group coprocessor cmds
    ../../FT812 APIs/coprocessor commands/: Ft81x_copro_cmds.c Ft81x_copro_cmds.h
  group image loading
    ../../FT812 APIs/image loading/: image_loading.c image_loading.h
  group screens
    ../../screens/: screens.h screens.c
